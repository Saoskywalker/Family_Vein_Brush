# IAR project Gyro Program.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: User Inc; ST Inc; Library\delay; Library\MPU6050
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Gyro Program.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Library/delay
    Library/delay/: delay.c
  group Library/MPU6050
    Library/MPU6050/: mpu6050.c mpuiic.c
  group ST Src
    ST Src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_it.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
  group User Src
    User Src/: main.c UART_Frame.c UserBaseLib.c
